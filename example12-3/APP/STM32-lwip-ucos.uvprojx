# Keil uVision project STM32-lwip-ucos.uvprojx, settings and files
target STM32-LWIP-uCOSII (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x00040000) IRAM(0x20000000,0x0000C000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32-lwip-ucos +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210B_EVAL
  c include: ..\APP;..\BSP;..\FWLib\inc;..\Startup;..\uCOS-II\Source;..\uCOS-II\uC-CPU;..\uCOS-II\uC-LIB;..\uCOS-II\Ports;..\CM3;..\lwip\src\api;..\lwip\src\arch;..\lwip\src\include;..\lwip\src\netif;..\lwip\src\include\ipv4;..\Source\inc;..\lwip\src;..\Source\inc\src;..\lwip\src\include\lwip
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Startup
    ../Startup/: stm32f10x_startup.s
  group FWLib
    ../FWlib/SRC/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_exti.c
  group uC-OS-II/Port
    ../uCOS-II/Ports/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group uC-OS-II/CPU
    ../uCOS-II/uC-CPU/: cpu_a.asm
  group uC-OS-II/Source
    ../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group Documentation
    ./: readme.txt
  group CM3
    ../CM3/: core_cm3.c system_stm32f10x.c
  group SRC
    ../Source/src/: main.c lwipdemo.c stm32f10x_it.c bsp.c httpserver-netconn.c
  group lwip-arch
    ../lwip/src/arch/: cc.h ENC28J60.C ENC28J60.H lwipopts.h perf.h SPI.C SPI.H sys_arch.c sys_arch.h
  group lwip-netif
    ../lwip/src/netif/: etharp.c ethernetif.c loopif.c slipif.c
  group lwip-core
    ../lwip/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group lwip-core-ipv4
    ../lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group lwip-api
    ../lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
